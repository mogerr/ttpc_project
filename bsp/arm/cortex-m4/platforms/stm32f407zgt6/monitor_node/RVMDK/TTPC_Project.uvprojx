# Keil uVision project TTPC_Project.uvprojx, settings and files
target STM32F407ZG_TTPC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TTPC_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER TTP_DEBUG STM32F40_41xxx
  c include: ..\CPU;..\FWLIB\inc;..\STARTUP;..\..\..\..\..\..\..\include;..\..\..\..\..\..\..\mac;..\..\..\..\..\..\..\medl;..\..\..\..\..\..\..\protocol;..\..\..\..\..\..\..\service;..\..\..\..\..\..\..\virthw;..\HARDWARE;..\..\..\..\..\..\..\dbg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\LAYOUT\ttpc_stm32f407zgt6.sct
  group STARTUP
    ../STARTUP/: main.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s host.c
  group CPU
    ../CPU/: cpu.c
  group LAYOUT
    ../LAYOUT/: mem.c
  group HARDWARE
    ../HARDWARE/: clock.c crc.c led.c lsens.c usart.c xfer.c
  group MEDL
    ../MEDL/: medl_data.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_fsmc.c
  group SYSTEM
    ../../../../../../../dbg/: debug.c ttp_assert.c
  group TTPC
    ../../../../../../../mac/: ctrl.c msg.c param.c phases_index.c prp.c psp.c slots.c tp.c
    ../../../../../../../medl/: medl.c
    ../../../../../../../protocol/: active.c await.c cold_start.c download.c freeze.c init.c listen.c passive.c state_machine_direct.c test.c
    ../../../../../../../service/: ack.c clique.c core.c integrate.c slot_acquirement.c sync.c
